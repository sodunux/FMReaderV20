# Keil uVision project CCID Reader uCos-II.uvprojx, settings and files
target CCID Reader uCos-II (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CCID Reader uCos-II +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,
  c include: ..\Code\APP\inc;..\Code\BSP;..\Code\CM3;..\Code\ContactCard;..\Code\ContactlessCard;..\Code\STM32F10x_StdPeriph_Driver\inc;..\Code\STM32_USB-FS-Device_Driver\inc;..\Code\uCOS-II_Ports;..\Code\uCOS-II_Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../Code/APP/src/: app.c CCID.c SpecialAPDU.C stm32f10x_it.c
  group STM32 FW
    ../Code/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Code/CM3/: startup_stm32f10x_md.s system_stm32f10x.c
  group UCOS
    ../Code/uCOS-II_Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../Code/uCOS-II_Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group BSP
    ../Code/BSP/: bsp.c retarget.c
  group ContactCard
    ../Code/ContactCard/: smartcard.c ContactCard.C
  group ContactlessCard
    ../Code/ContactlessCard/: ContactlessCard.C FM320.c
  group USB
    ../Code/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c

# Keil uVision project FM320_Demo.uvprojx, settings and files
target FM320 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FM320_Verify +hex
  c flags: Optim=1
  c include: ..\library\inc;..\USER_SRC\Func\INC;..\USER_SRC\Global_lib\INC;..\USER_SRC\HW_Lib\INC;..\USER_SRC\LPCD\INC;..\USER_SRC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../: cortexm3_macro.s STM32F10x.s
    ../USER_SRC/: main.c stm32f10x_it.c Detail.txt
  group Lib
    ../library/src/: stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim1.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_dma.c
  group HW_Lib
    ../USER_SRC/HW_Lib/SRC/: DEVICE_CFG.C I2C.C oled.c UART.C AD_DATA_Process.c
  group Func
    ../USER_SRC/Func/SRC/: BasicAPI.c CardAPI.c ReaderAPI.c RegCtrl.c Demo.c
  group LPCD
    ../USER_SRC/LPCD/SRC/: lpcd_api_private.c lpcd_api_public.c lpcd_regctrl_private.c
  group Global_Lib
    ../USER_SRC/Global_lib/SRC/: debug.c global.c
